# Keil uVision project top.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: code +hex
  AfterMake: fromelf -cvf .\objects\code.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf  .\objects\code.axf -o disasm.txt
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: cm0dsasm.s main.c
